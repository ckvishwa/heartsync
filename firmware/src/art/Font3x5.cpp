#include "art/Font3x5.h"

namespace hs {
namespace font3x5 {

namespace {

struct Glyph {
    char c;
    uint8_t rows[kHeight];
};

// clang-format off
constexpr Glyph kGlyphs[] = {
    {' ', {0, 0, 0, 0, 0}},
    {'A', {2, 5, 7, 5, 5}}, {'B', {6, 5, 6, 5, 6}}, {'C', {3, 4, 4, 4, 3}},
    {'D', {6, 5, 5, 5, 6}}, {'E', {7, 4, 6, 4, 7}}, {'F', {7, 4, 6, 4, 4}},
    {'G', {3, 4, 5, 5, 3}}, {'H', {5, 5, 7, 5, 5}}, {'I', {7, 2, 2, 2, 7}},
    {'J', {1, 1, 1, 5, 2}}, {'K', {5, 5, 6, 5, 5}}, {'L', {4, 4, 4, 4, 7}},
    {'M', {5, 7, 7, 5, 5}}, {'N', {6, 5, 5, 5, 5}}, {'O', {2, 5, 5, 5, 2}},
    {'P', {6, 5, 6, 4, 4}}, {'Q', {2, 5, 5, 6, 3}}, {'R', {6, 5, 6, 5, 5}},
    {'S', {3, 4, 2, 1, 6}}, {'T', {7, 2, 2, 2, 2}}, {'U', {5, 5, 5, 5, 7}},
    {'V', {5, 5, 5, 5, 2}}, {'W', {5, 5, 7, 7, 5}}, {'X', {5, 5, 2, 5, 5}},
    {'Y', {5, 5, 2, 2, 2}}, {'Z', {7, 1, 2, 4, 7}},
    {'0', {7, 5, 5, 5, 7}}, {'1', {2, 6, 2, 2, 7}}, {'2', {6, 1, 2, 4, 7}},
    {'3', {6, 1, 2, 1, 6}}, {'4', {5, 5, 7, 1, 1}}, {'5', {7, 4, 6, 1, 6}},
    {'6', {3, 4, 7, 5, 7}}, {'7', {7, 1, 2, 2, 2}}, {'8', {7, 5, 7, 5, 7}},
    {'9', {7, 5, 7, 1, 6}},
    {'-', {0, 0, 7, 0, 0}}, {'.', {0, 0, 0, 0, 2}}, {':', {0, 2, 0, 2, 0}},
    {'!', {2, 2, 2, 0, 2}}, {'?', {6, 1, 2, 0, 2}}, {'/', {1, 1, 2, 4, 4}},
};
// clang-format on

}  // namespace

const uint8_t* glyph(char c) {
    if (c >= 'a' && c <= 'z') {
        c = static_cast<char>(c - 'a' + 'A');
    }
    for (const Glyph& g : kGlyphs) {
        if (g.c == c) {
            return g.rows;
        }
    }
    return glyph('?');
}

uint16_t textWidth(const char* text) {
    uint16_t n = 0;
    for (const char* p = text; p != nullptr && *p != '\0'; ++p) {
        ++n;
    }
    return n == 0 ? 0 : static_cast<uint16_t>(n * kAdvance - 1);
}

}  // namespace font3x5
}  // namespace hs
